# Keil uVision project STM32FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,FreeRTOS_OS
  c include: ..\1.STMDrivers\CMSIS;..\1.STMDrivers\STM32F10x_StdPeriph_Driver\inc;..\2.User;..\2.User\BSP;..\5.FreeRTOS\include;..\5.FreeRTOS\port\RVDS\ARM_CM3;..\2.User\BSP\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../1.STMDrivers/Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../1.STMDrivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group STMDrivers
    ../1.STMDrivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/Source
    ../5.FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../5.FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../5.FreeRTOS/port/MemMang/: heap_4.c
  group User
    ../2.User/: main.c stm32f10x_it.c
  group BSP
    ../2.User/BSP/USART/: bsp_usart.c
    ../2.User/BSP/LED/: bsp_led.c
    ../2.User/BSP/ChipID/: bsp_chipid.c
    ../2.User/BSP/IIC/: bsp_i2c.c
    ../2.User/BSP/MOTOR/: bsp_motor.c bsp_encoder.c
    ../2.User/BSP/PID/: bsp_pid.c
    ../2.User/BSP/MPU6050/: bsp_mpu6050.c
  group Doc
    ../6.Doc/: readme.h
